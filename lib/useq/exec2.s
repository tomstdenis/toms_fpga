; testing exec2
.MODE 2
ADD 0, 1
SUB 1, 2
EOR 2, 3
AND 3, 0
OR  0, 3
MOV 1, 0
NEG 2
CLR 3
LDI 0, FF
XCH 1
LDIND1 0
LDIND2 1
STIND1 2
STIND2 3
SIGT 0,1
SIEQ 2,3
SILT 0, 3
ASR 0
LSR 1
ADDA 2
SUBA 3
RFIFO 0
WFIFO 1
QFIFO 2
WAITF 3
ANDA 0
ORA 1
EORA 2
LDA 3
JNZ 1,FE
JZ 2,	FD
DEC 0
INC 1
JMP FC
CALL FB
RET
RTI
IN
OUT
EXEC1
WAITA
SEI 2
