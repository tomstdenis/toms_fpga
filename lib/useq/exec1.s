; testing every opcode
LD 1
ST 2
SETB 3,1
ADD 4
SUB 5
EOR 6
AND 7
OR 8
JMP 3
JNZ 4
INC
DEC
ASL
LSR
ASR
SWAP
ROL
ROR
SWAPR0
SWAPR1
NOT
CLR
LDA
SIGT
SIEQ
SILT
LDIB 9
LDIT A
OUT
OUTBIT
TGLBIT
IN
INBIT
NEG
SEI
JMPA
CALL
RET
RTI
WAIT0
WAIT1
EXEC2
WAITF
WAITA
JSR B0
SBIT 5,0
