.ORG 00
    LDIB F
    LDIT F
:LOOP
    TGLBIT
    WAITA      ; A counts down to 0, then restores to 0xFF
    JNZ LOOP   ; A is 0xFF, so we jump back 1 to 16 bytes

.ALIGN 10
:BOOT
LD 0xF
ST A
LDIT <TOM
LDIB >TOM
.EQU TOM 23
LD 5
ST 7
SETB 2, 0
SETB 2, 1
SETB 4, 1
SBIT 7, 1
SBIT 7, 0
; comment
JSR 0xF
JSR ISR
LDIB <TOM
LDIB >TOM

.ORG F0
:ISR
LDIB >TOM
LDIB <TOM
INC
:ISR1
LDIB >ISR1
LDIB <ISR1
DEC
JNZ ISR
JNZ 3
